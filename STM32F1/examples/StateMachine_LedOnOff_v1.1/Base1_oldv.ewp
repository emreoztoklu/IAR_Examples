# IAR project Base1_oldv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\IAR_Examples\STM32F1\Libraries\STM32F10x_StdPeriph_Driver\src; ..\..\..\..\IAR_Examples\STM32F1\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\IAR_Examples\STM32F1\examples\StateMachine_LedOnOff_v1.1\user\src; ..\..\..\..\IAR_Examples\STM32F1\examples\StateMachine_LedOnOff_v1.1\user\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Base1.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Core
    user/: delay.s startup_stm32f10x_md.s
    user/inc/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
    user/src/: stm32f10x_it.c system_stm32f10x.c
  group Peripheral
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group user
    user/src/: io.c main.c system.c
    ./: io.h system.h
