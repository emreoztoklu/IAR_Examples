# IAR project Backup_I2C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\src; D:\2_Projects\IAR_Examples\STM32F1\examples\5_BUTTON\user\inc; D:\2_Projects\IAR_Examples\STM32F1\examples\5_BUTTON\user\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Base1.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Core
    user/: delay.s startup_stm32f10x_md.s
    user/inc/: stm32f10x.h stm32f10x_it.h system_stm32f10x.h
    user/src/: stm32f10x_it.c system_stm32f10x.c
  group Peripheral
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group user
    user/src/: button.c io.c lcdm.c main.c system.c uart.c
    user/inc/: button.h io.h lcdm.h system.h uart.h
